## config/Kconfig.shield
```kconfig
config SHIELD_CALDERA_LEFT
    def_bool $(shields_list_contains,corne_left)

config SHIELD_CALDERA_RIGHT
    def_bool $(shields_list_contains,corne_right)
```
